<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\07_can_sender.ewp</path>
  </project>
  <batchBuild />
</workspace>
